# Keil uVision project 328-DS1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 305-DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: smg.c smg.h main.c delay.c delay.h ds1302.h ds1302.c
